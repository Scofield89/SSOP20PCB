# Repository Scofield89/SSOP20PCB

## KiCad design SSOP20DevBoard.kicad_pcb

Parts:
J1, J2: Conn_01x10_Male; PinHeader_1x10_P2.54mm_Vertical
U1: AD; MCP310

Connections:
unnamed: J1.1, U1.1 (~Reset/OSR0)
unnamed: J1.2, U1.2 (DV_DD)
unnamed: J1.3, U1.3 (AV_DD)
unnamed: J1.4, U1.4 (CH0+)
unnamed: J1.5, U1.5 (CH0-)
unnamed: J1.6, U1.6 (CH1+)
unnamed: J1.7, U1.7 (CH1-)
unnamed: J1.8, U1.8 (A_GND)
unnamed: J1.9, U1.9 (REFIN+/OUT)
unnamed: J1.10, U1.10 (REFIN-)
unnamed: J2.1, U1.11 (D_GND)
unnamed: J2.2, U1.12 (MDAT1)
unnamed: J2.3, U1.13 (MDAT0)
unnamed: J2.4, U1.14 (~DR/GAIN1)
unnamed: J2.5, U1.15 (OSC1/CLKI/GAIN0)
unnamed: J2.6, U1.16 (OSC2/Mode)
unnamed: J2.7, U1.17 (~CS/Boost)
unnamed: J2.8, U1.18 (SCK/MCLK)
unnamed: J2.9, U1.19 (SDO)
unnamed: J2.10, U1.20 (SDI/OSR1)

Board: 2 copper layers, 27.9 x 27.9 mm, 3 parts (0 on the bottom side), 20 nets.

## Commit log

2023-01-11 SSOP20V1.0
2023-07-11 changed pin connectors to correct size
2023-07-12 cleaning
2023-07-12 changed pad size
